# Repository TMPI5235/303ODv2.3

## KiCad design 303_ODv2_3.kicad_pcb

Parts:
C1, C3: 0.1u; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: C_Polarized; CP_Elec_6.3x5.4
D1, D6: Yellow; LED_0603_1608Metric
D7: USR1; LED_0603_1608Metric
D8: USR2; LED_0603_1608Metric
D9: USR3; LED_0603_1608Metric
D10: PWR; LED_0603_1608Metric
D11: CUHS20S30; D_TUMD2
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad
J1, J11: 5V_IO; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J2: SPI_PA7,6,5,3; PinHeader_1x04_P2.54mm_Vertical
J3: ENC2; JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical
J4: ENC1; JST_XA_B05B-XASK-1_1x05_P2.50mm_Vertical
J5: PA1; PinHeader_1x02_P2.54mm_Vertical
J6: PA1; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J7: PA0; PinHeader_1x02_P2.54mm_Vertical
J8: PA0; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J9: CAN1A; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J10: CAN1B; Kai_LAN_RJ45_Neltron_Industrial_7810-8P8C
J12: UART/I2C; JST_XA_B02B-XASK-1_1x02_P2.50mm_Vertical
J14: CAN; JST_GH_SM02B-GHS-TB_1x02-1MP_P1.25mm_Horizontal
JP1: I2C-5V; solderbridge
JP2: PA1; solderbridge
JP3: NRST-3V3; solderbridge
JP6: AP0; solderbridge
JP7: USR1; solderbridge
JP8: USR2; solderbridge
JP9: USR3; solderbridge
JP10: PA1-Buz; solderbridge
JP11: 5v-Buz; solderbridge
LS1: UGCT7525AN4
Q1: 2N7002K; SOT-23
R1, R2: 2k2; R_0805_2012Metric
R3, R6: 1k; R_0805_2012Metric
R4: 100R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R7, R8, R9: 500R; R_0805_2012Metric
R10: 120R; R_0805_2012Metric
R11: 1K; R_0805_2012Metric
R12: 200R; R_0805_2012Metric
R13: 2K; R_0805_2012Metric
SW1: USR1; SW_SPST_PTS810_HandSolder
SW2: USR2; SW_SPST_PTS810_HandSolder
SW3: USR3; SW_SPST_PTS810_HandSolder
SW4: SW_DPDT_x2; slide_SW
SW5: NRST; SW_SPST_PTS810_HandSolder
U1: NUCLEO-F303K8; MODULE_NUCLEO-F303K8; PARTREV 5
U2: MCP2561-E-P; DIP-8_W7.62mm
U3: BNO055_aki; BNO055_Board

Connections:
+3V3: JP3.1 (A), U1.4_14 (+3V3)
+5V: C1.2, C2.1, C3.2, J1.2, J3.4, J4.4, J9.7, J9.8, J10.7, J10.8, J11.2, JP1.2 (B), JP11.1 (A), R11.1, U1.4_4 (+5V), U2.3 (VDD), U3.1 (VIN)
BUZZER: J5.2, J6.2, JP2.1 (A), JP10.1 (A), U1.4_11 (PA1)
CANH: J9.1, J10.1, J14.2, R10.2, U2.7 (CANH)
CANL: J9.2, J10.2, J14.1, SW4.2 (B), U2.6 (CANL)
CAN_RD: U1.3_13 (PA11), U2.4 (RXD)
CAN_TD: U1.3_5 (PA12), U2.1 (TXD)
ENC1A_PA9: J4.3, U1.3_1 (PA9)
ENC1B_PA8: J4.5, U1.3_12 (PA8)
ENC2A_PB5: J3.3, U1.3_14 (PB5)
ENC2B_PB4: J3.5, U1.3_15 (PB4)
GND: C1.1, C2.2, C3.1, D1.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), H1.1, H2.1, H3.1, H4.1, J1.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.4, J9.5, J10.4, J10.5, J11.1, Q1.2 (S), R13.1, SW1.2, SW2.2, SW3.2, SW5.2, U1.3_4 (GND_1), U1.4_2 (GND_2), U2.2 (VSS), U2.8 (STBY), U3.2 (GND)
GPIO_PA0: J7.2, J8.2, JP6.1 (A), U1.4_12 (PA0)
I2C_SCL: J12.2, R1.1, U1.3_8 (PB6), U3.4 (SCL/R)
I2C_SDA: J12.1, R2.1, U1.3_7 (PB7), U3.3 (SDA/T)
NRST: R4.1, SW5.1, U1.4_3 (NRST_2)
unnamed: D1.2 (A), R3.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R11.2
unnamed: D11.1 (K), JP11.2 (B), LS1.1
unnamed: D11.2 (A), LS1.2, Q1.3 (D)
unnamed: JP1.1 (A), R1.2, R2.2
unnamed: JP2.2 (B), R3.1
unnamed: JP3.2 (B), R4.2
unnamed: JP6.2 (B), R6.1
unnamed: JP7.2 (B), R7.1
unnamed: JP8.2 (B), R8.1
unnamed: JP9.2 (B), R9.1
unnamed: JP10.2 (B), R12.1
unnamed: Q1.1 (G), R12.2, R13.2
unnamed: R10.1, SW4.3 (C)
SPI1_MISO_PA6: J2.2, U1.4_7 (PA6)
SPI1_MOSI_PA7: J2.1, U1.4_6 (PA7)
SPI1_SCK_PA5: J2.3, U1.4_8 (PA5)
SPI1_SSEL_PA3: J2.4, U1.4_10 (PA3)
USR_LED1: JP7.1 (A), U1.3_6 (PB0)
USR_LED2: JP8.1 (A), U1.3_9 (PB1)
USR_LED3: JP9.1 (A), U1.4_9 (PA4)
USR_SW1: SW1.1, U1.3_2 (PA10)
USR_SW2: SW2.1, U1.3_10 (PF0)
USR_SW3: SW3.1, U1.3_11 (PF1)

Notes on the sheet:
専用 ENC1>TIM1-ch1.ch2>PA8,PA9 ENC2>TIM3-ch1,ch2>PB4,PB5 Motor1>TIM15-ch2,ch1N>PA3,PA1 Motor2>TIM16-1,TIM17-1>,PA6,PA7 CAN>TD,RD>PA12,PA11
排他 PA5[A4]<->PB7[D4] PA6[A5]<->PB6[D5] SB16,SB18を外さなければ、A4,A5をI2Cとして使用できる

Board: 2 copper layers, 72.4 x 47.3 mm, 58 parts (9 on the bottom side), 44 nets.
